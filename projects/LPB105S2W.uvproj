# Keil uVision project LPB105S2W.uvproj, settings and files
target LPB105S2W (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: LPB105S2W +hex
  AfterMake: fromelf.exe --bin --output ./output/LPB105S2W.bin ./output/LPB105S2W.axf
  AfterMake: ../tools/LPB100_IMG_TOOLS/LPB100_IMG_Tools.exe ./output/LPB105S2W.bin ./output/LPB105S2W_UPGARDE.bin
  c flags: OneElfS=1
  c define: __KEIL_MDK__ ZC_MODULE_VERSION=0 ZC_MODULE_TYPE=1 __LPB105__ xZC_MODULE_DEV
  c misc: --diag_suppress=494  --c99
  c include: ../sdk/1.50/include/;..\src\ZC\inc\\aes;..\src\ZC\inc\tropicssl;..\src\ZC\inc\zc;..\src;..\src\AC\inc
  scatter file: LPBS2W.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr)
  group src
    ../src/: startup.c app_main.c
  group libs
    ../sdk/1.50/libs/: LPB100Kernel.lib
  group zc_src
    ../src/ZC/src/zc/: zc_client_manager.c zc_cloud_event.c zc_common.c zc_message_queue.c zc_moudle_manager.c zc_protocol_controller.c zc_sec_engine.c zc_timer.c zc_bc.c zc_configuration.c
    ../src/ZC/src/tropicssl/: bignum.c rsa.c
    ../src/ZC/src/crc/: crc.c
  group zc_inc
    ../src/ZC/inc/tropicssl/: bignum.h bn_mul.h rsa.h secconfig.h
    ../src/ZC/inc/zc/: zc_client_manager.h zc_cloud_event.h zc_common.h zc_message_queue.h zc_module_config.h zc_module_interface.h zc_protocol_controller.h zc_protocol_interface.h zc_sec_engine.h zc_timer.h
  group aes
    ../src/ZC/src/aes/: aes_cbc.c aes_core.c
  group zc_adpter
    ../src/: zc_hf_adpter.c
  group ac_src
    ../src/AC/src/: ac_api.c ac_hal.c
